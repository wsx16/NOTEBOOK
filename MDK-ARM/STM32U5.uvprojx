# Keil uVision project STM32U5.uvprojx, settings and files
target STM32U5 (6240000::V6.24::ARMCLANG)
  device: STM32U575RITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: STM32U5 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx,LV_LVGL_H_INCLUDE_SIMPLE=1
  c include: ../Core/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include/;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/;../Middlewares/Third_Party/CMSIS/RTOS2/Include/;../Core/mqtt;../Core/modbus;../Core/LCD;../Core/lvgl;../Core/lvgl/src;../Core/lvgl/examples/porting;../Core/lvgl/guider/src/custom;../Core/lvgl/guider/src/generated;../Core/lvgl/guider/src/generated/guider_fonts
  asm include: ../Middlewares/Third_Party/CMSIS/RTOS2/Include/
  library: MicroLIB
  memory RVCT4: ROM 0x800a000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c i2c.c icache.c spi.c tim.c usart.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group modbus
    ../Core/modbus/: modbus.c modbus.h
  group mqtt
    ../Core/mqtt/: mqtt.c mqtt.h
    ../Core/Src/: gui_wifi.c
  group LCD
    ../Core/LCD/: bsp_ili9341_4line.c bsp_ili9341_4line.h bsp_ft6336.c bsp_ft6336.h
  group LVGL_GUI
    ../Core/lvgl/guider/src/custom/: custom.c
    ../Core/lvgl/guider/src/generated/guider_fonts/: lv_font_montserratMedium_12.c lv_font_SourceHanSerifSC_Regular_10.c lv_font_SourceHanSerifSC_Regular_12.c lv_font_SourceHanSerifSC_Regular_21.c
    ../Core/lvgl/guider/src/generated/images/: _1_alpha_100x100.c _2_alpha_240x320.c _3_alpha_240x320.c _4_alpha_240x320.c _5_alpha_240x320.c _6_alpha_240x320.c _7_alpha_240x320.c
    ../Core/lvgl/guider/src/generated/: events_init.c gui_guider.c setup_scr_screen.c setup_scr_screen_1.c setup_scr_screen_2.c setup_scr_screen_3.c widgets_init.c
  group LVGL_Conf
    ../Core/lvgl/: lvgl.h lv_conf.h
  group LVGL_porting
    ../Core/lvgl/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group LVGL_src
    ../Core/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Core/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Core/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Core/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../Core/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Core/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Core/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Core/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Core/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Core/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Core/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Core/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Core/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Core/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Core/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Core/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Core/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Core/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Core/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Core/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Core/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Core/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Core/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Core/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Core/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Core/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Core/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Core/lvgl/src/extra/others/msg/: lv_msg.c
    ../Core/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Core/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Core/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Core/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Core/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Core/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Core/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Core/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Core/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Core/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Core/lvgl/src/extra/widgets/led/: lv_led.c
    ../Core/lvgl/src/extra/widgets/list/: lv_list.c
    ../Core/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Core/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Core/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Core/lvgl/src/extra/widgets/span/: lv_span.c
    ../Core/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Core/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Core/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Core/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Core/lvgl/src/extra/widgets/win/: lv_win.c
    ../Core/lvgl/src/extra/: lv_extra.c
    ../Core/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Core/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Core/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Core/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.6.0
